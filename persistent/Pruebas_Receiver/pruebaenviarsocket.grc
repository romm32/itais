options:
  parameters:
    generate_options: qt_gui
    id: pruebasocket
    output_language: python
    title: socket
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from datetime import datetime, timedelta
      import zmq

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.float32)],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              self.lim = 5
              self.arr = np.full(2, 33)
              self.dict = {"slot": 3, "puedo": 3}
              self.slots_per_minute = 2250
              self.slot_index = 0
              self.unavez = True

          def work(self, input_items, output_items):
          
              current_utc_time = datetime.utcnow()
              start_of_minute = current_utc_time.replace(second=0, microsecond=0)
              time_elapsed = current_utc_time - start_of_minute
              milliseconds_elapsed = time_elapsed.total_seconds() * 1000
              self.slot_index = (milliseconds_elapsed)*self.slots_per_minute/60000 #Cantidad de slots desde que empezó el minuto.
              
              context = zmq.Context()
              socket = context.socket(zmq.PUB)
              socket.bind("tcp://127.0.0.1:5620")  # Connect to the same port as in your GNU Radio script
              self.dict["slot"] = int(self.slot_index)
              
              socket.send_string(f"{self.dict}")
              if self.unavez:
                  print("envio")
                  self.unavez = False
              
              return 2
    comment: esta parte envia arreglos de dim 2
    example_param: '1.0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0_0_0, '0']

metadata:
  file_format: 1
