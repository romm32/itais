options:
  parameters:
    generate_options: qt_gui
    id: taggeando
    output_language: python
    title: prueba_tags
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport zmq\nimport struct\nfrom datetime import datetime\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.complex64, np.float32],\n            out_sig=[np.complex64]\n        )\n        #context = zmq.Context() # no es posible definir el socket arriba del todo, y definirlo una sola vez. gnu radio no funciona.\n        #socket = context.socket(zmq.PUB)\n        #socket.bind(\"tcp://127.0.0.1:5580\")\n        \n        self.topic = \"valores_umbral_potencia\"\n        \n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n        \n        self.contador = 1\n        self.inicio = 41\n        self.final = 99\n        self.cant_muestras_enviadas = 0\n        \n        self.rangoinf = False\n        self.rangosup = False\n        self.recibi = False\n\n    def work(self, input_items, output_items):\n    \tin_buf = input_items[0]\n    \tout_buf = output_items[0]\n    \t\n    \t# subscriptor para cuando el transmisor avisa que necesita las muestras.\n    \t#context = zmq.Context()\n    \t#subscriber = context.socket(zmq.SUB)\n    \t#subscriber.connect(\"tcp://127.0.0.1:5590\")  # Connect to the same port as in your GNU Radio script\n    \t#subscriber.setsockopt_string(zmq.SUBSCRIBE, \"\")\n    \t\n    \t#msj = subscriber.recv_string()\n    \t#print(\"esperando mensaje\")\n    \tmsj = input_items[1][0]\n    \tmsj = struct.unpack('!f', msj)[0]\n    \t#print(\"msg: \", msj)\n    \tif msj == 1:\n    \t\tself.recibi = True\n    \t\t#print(\"llego mensaje, enviando\")\n    \t\t#print(\"len input items0:\", len(input_items[0]))\n    \t\t#print(\"len input items1:\", len(input_items[1]))\n    \t\n    \t\n    \tif self.recibi:\n    \t\t#print(\"recibi len input items0:\", len(input_items[0]))\n    \t\t#print(\"recibi len input items1:\", len(input_items[1]))\n    \t\n    \t\tcontext = zmq.Context()\n    \t\tsocket = context.socket(zmq.PUB)\n    \t\tsocket.bind(\"tcp://127.0.0.1:5580\")\n\n    \t\t\n    \t\tfor i in range(0, len(input_items[0])):\n    \t\t\t\n    \t\t\tif 41 <= self.contador and self.contador <= 99 and ((not self.rangoinf) or (not self.rangosup)):\n    \t\t\t\tif self.contador == 41:\n    \t\t\t\t\tself.rangoinf = True\n    \t\t\t\tif self.contador == 99:\n    \t\t\t\t\tself.rangosup = True\n    \t\t\t\tdatos = {\"num_muestra\": self.contador, \"umbral\": in_buf[0], \"potencia_actual\": in_buf[0]*2}\n    \t\t\t\tmessage_info = f\"{self.topic} {datos}\"#.encode('utf-8')\n    \t\t\t\tsocket.send_string(message_info)\n    \t\t\t\tself.cant_muestras_enviadas += 1\n    \t\t\t\t#print(\"enviada muestra: \", self.contador)\n    \t\t\tself.contador = self.contador + 1\n    \t\t\tif self.contador == 1356:\n    \t\t\t\tself.contador = 1\n    \t\t\t\tself.rangoinf = False\n    \t\t\t\tself.rangosup = False\n    \t\t\t\tself.recibi = False\n    \t\t\tif self.cant_muestras_enviadas >= 500 and self.cant_muestras_enviadas < 510:\n    \t\t\t\tif self.cant_muestras_enviadas == 500:\n    \t\t\t\t\tcurrent_time = datetime.now()\n    \t\t\t\t\tformatted_time = current_time.strftime(\"%Y-%m-%d %H:%M:%S\")\n    \t\t\t\t\tprint(\"rx llego a 500\", formatted_time)\n    \t\t\t\t\t\n\t    \t\n\t    \t\t\n\n\t    \tsocket.close()\n\t    \tcontext.term()\n\t    \t#print(\"cerrando socket\")\n\t    \t\n    \toutput_items[0][:] = input_items[0]\n    \t#self.set_output_multiple(100)\n    \treturn 100\n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n"
    example_param: '1.0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Sink PUB"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Sink SUB"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5590
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', zeromq_pub_sink_0, '0']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_1, '0']
- [zeromq_sub_source_1, '0', epy_block_0, '1']

metadata:
  file_format: 1
