options:
  parameters:
    generate_options: qt_gui
    id: receiveOnly
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '5000'
    msg: pmt.intern("TEST")
    std: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_rep_msg_sink_0
  id: zeromq_rep_msg_sink
  parameters:
    address: tcp://127.0.0.1:50247
    timeout: '100'
  states: {}

connections:
- [blocks_message_strobe_random_0, strobe, zeromq_rep_msg_sink_0, in]
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
