options:
  parameters:
    generate_options: qt_gui
    id: pruebasdic
    output_language: python
    title: pruebasdicc
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import zmq

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              context = zmq.Context()
              subscriber = context.socket(zmq.SUB)
              subscriber.connect("tcp://127.0.0.1:5600")  # Connect to the same port as in your GNU Radio script
              subscriber.setsockopt_string(zmq.SUBSCRIBE, "")
              msj = subscriber.recv_string()
              print(msj)
              
              return 100
    example_param: '1.0'
  states: {}

connections:
- [epy_block_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
