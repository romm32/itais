options:
  parameters:
    generate_options: qt_gui
    id: prueba_SUB
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
    update_time: '0.0010'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:5556
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_number_sink_0, '0']
- [zeromq_sub_source_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
