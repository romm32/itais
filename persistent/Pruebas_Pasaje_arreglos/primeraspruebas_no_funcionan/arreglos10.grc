options:
  parameters:
    generate_options: qt_gui
    id: pasajearreglos
    output_language: python
    title: pasandoarreglos
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: float
    vlen: '10'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          def __init__(self, example_param=1.0):  # only default arguments here
          	"""arguments to this function show up as parameters in GRC"""
          	gr.sync_block.__init__(
              self,
              name='Embedded Python Block',   # will show up in GRC
              in_sig=[(np.float32, 10)],
              out_sig=[]
          )
          # if an attribute with the same name as a parameter is found,
          # a callback is registered (properties work, too).
          	self.example_param = example_param
          	self.limite = 10
          
          def work(self, input_items, output_items):
          	if all(input_items[0][0] == [2, 3, 4, 5, 6, 7, 8, 9, 10, 11]):
          		print("si")
          		self.limite = self.limite - 1
          	return len(input_items[0])
    example_param: '1.0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:6001
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:6000
    timeout: '100'
    type: float
    vlen: '10'
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', epy_block_0, '0']
- [zeromq_sub_source_0_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
