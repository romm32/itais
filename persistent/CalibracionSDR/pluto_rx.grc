options:
  parameters:
    generate_options: qt_gui
    id: pluto_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: const
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 2**15-1
    value: 2**15-1
  states: {}
- name: psize
  id: variable
  parameters:
    value: '8972'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: const
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/1000
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: const
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '5005'
    psize: psize
    type: short
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '5005'
    psize: psize
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_source_1
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '5005'
    psize: 8972*2
    type: short
    vlen: '1'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\n\n\"\"\"\nBloque que implementa un mecanismo análogo a \"Potumbral\"\npara el cálculo de la potencia de las muestras.\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport math\n# Bloque de Python utilizado al momento de calibrar el SDR con el analizador de espectros.\n\n\nclass blk(gr.sync_block): \n\tdef __init__(self, designator=\"B\"): \n\t\tgr.sync_block.__init__(self,name='Embedded Python Block',in_sig=[np.complex64],out_sig=[np.complex64])\n\t\tself.designator = designator\n\t\tself.arr_pow_actual = np.full(50, 2e-14)\n\t\tself.power = 2e-7\n\t\tself.prommovil = 0\n\t\tself.pow_db = 0\n\t\tself.contador = 0\n\t\tself.sumador = 0\n\t\tself.pow_actual = 1\n\t\tself.i = 0\n\t\tself.N = 100 #Cantidad de iteraciones del for correspondiente a 20ms\n\t\tself.subintervalos = 0\n\t\tself.N_muestras = []\n\t\tself.pow_4s = np.zeros(200)\n\t\t\n\t\tself.pow_minuto = [2e-14, 2e-14, 2e-14, 2e-14, 2e-14, 2e-14, 2e-14, 2e-14, 2e-14, 2e-14, 2e-14, 2e-14, 2e-14, 2e-14, 2e-14] #Se inicializa el arreglo para que el umbral de -107dBm=2e-14\n\t\t\n\t\tself.arr_pow_actual = np.full(5, 2e-14) #Se inicializa el arreglo que determina la potencia actual con el promedio. Se toma un promedio movil del ultimo ms (5 muestras) iniciando con una potencia inicial igual al umbral minimo  \n\t\t\n\t\tself.umbral = 2e-14\n\t\t\n\t\tself.umb_y_pow_actual = np.zeros(2) #Se crea este arreglo que es lo que se le pasa al transmisor. Un umbral y una potencia actual en ese orden para que sepa interpretarlo.\n\t\tself.salida_db = np.zeros(2) #Se crea este arreglo que es lo que se le pasa al transmisor. Un umbral y una potencia actual en ese orden para que sepa interpretarlo.\n\t\t\n\t\tself.umbral_actual = 1\n\t\t\n\t\tself.salida = np.zeros(2)\n\n\t\tself.pow_avg = 2e-7\n\t\t\n\t\tself.subint = 0\n\t\t\n\n\n\tdef work(self, input_items, output_items):\n\t\tif self.designator == \"B\":\n\t\t\tself.i = 0\n\t\t\twhile self.i < len(input_items[0]):\n\t\t\t\tself.pow_actual = np.abs(input_items[0][self.i])**2\n\t\t\t\tself.pow_actual = 10*math.log10(self.pow_actual)\n\t\t\t\tself.pow_actual = 0.9941*self.pow_actual -12.99\n\t\t\t\tif self.pow_actual == 0: #Caso de borde\n\t\t\t\t\tself.pow_actual = 1e-20\n\t\t\t\t\n\t\t\t\tself.umbral_actual = (10*math.log10(self.umbral/0.001)) + 10 #Se le suma 10dB al umbral, el umbral actual es el ultimo calculado que se actualiza cada 4s.\n\t\t\t\tself.salida_db[0] = self.umbral_actual\n\t\t\t\tself.salida_db[1] = self.pow_actual #10*math.log10(self.pow_actual/0.001)\n\t\t\t\t#self.salida_db[1] = 0.9941*self.salida_db[1] + 6.893 - 20\n\t\t\t\tself.N_muestras = np.append(self.N_muestras, self.pow_actual)\n\t\t\t\t\n\t\t\t\tself.N = self.N - 1\n\t\t\t\tif self.N == 0: #Si ya acumule la potencia de los ultimos 20 ms.\n\t\t\t\t\tself.pow_avg = np.mean(self.N_muestras) #Los 200 valores de potencia que se acumulan para formar los 4s es el promedio de los 20ms.\n\t\t\t\t\tself.N_muestras = []\n\t\t\t\t\tself.N = 100\n\t\t\t\t\tself.pow_4s[self.subintervalos] = self.pow_avg #Se acumulan los 200 valores de potencia para llegar a 4s.\n\t\t\t\t\tself.subintervalos += 1\n\t\t\t\t\t\n\t\t\t\tif self.subintervalos == 200: #Si completé los 200 subintervalos de 20ms tengo 4s y agarro el mínimo de eso.\n\t\t\t\t\tpo_4 = np.min(self.pow_4s)\n\t\t\t\t\tself.pow_minuto.pop(-1)\n\t\t\t\t\tself.pow_minuto.insert(0, po_4)\n\t\t\t\t\tself.umbral = np.min(self.pow_minuto)\n\t\t\t\t\tif self.umbral < 2e-14: #Si la potencia es menor a -107dBm se pone en -107dBm.\n\t\t\t\t\t\tself.umbral = 2e-14\n\t\t\t\t\t\n\t\t\t\t\telif self.umbral > 1.9e-5: #Si la potencia es mayor a -17dBm se pone en -17dBm (porque se suma 10dB después).\n\t\t\t\t\t\tself.umbral = 1.9e-5\n\t\t\t\t\t\n\t\t\t\t\tself.subintervalos = 0\n\t\t\t\t\tself.subint = self.subint+1\n\t\t\t\t\t\n\t\t\t\tself.i = self.i + 10\n\t\t\t\tself.contador = self.contador + 1\n\t\t\t\tif self.contador > 4000000 and self.contador < 4000050:\n\t\t\t\t\tprint(\"umbral: \", self.salida_db[0], \"potencia: \", self.salida_db[1])\n\t\t\t#else:\n\t\t\t#\tprint(\"potencia: \", self.salida_db[1])\n\t\t\t\t\n\t\t    \t\n\t\treturn 256\n"
    designator: '"B"'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '162025000'
    gain1: '''manual'''
    manual_gain1: '20'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '750000'
    uri: ip:192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '11000'
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"inicial"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"postishort"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"complextomag"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"nuestro"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"postishort'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_udp_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_freq_sink_x_0_2, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_nlog10_ff_1, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_udp_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_udp_source_1, '0', blocks_interleaved_short_to_complex_0, '0']
- [epy_block_0, '0', blocks_complex_to_float_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', epy_block_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
