options:
  parameters:
    generate_options: qt_gui
    id: pruebita
    output_language: python
    title: prueba
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: esta parte recibe arreglos de dim 10
    num_items: '10'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: complex
    vlen: '2'
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: complex
    vlen: '2'
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: complex
    vlen: '2'
  states: {state: disabled}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: complex
    vlen: '2'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[(np.complex64,10)],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n        self.lim = 5\n        self.arr = [0, 0, 0, 0, 0, 0, 0, 0, 0, 0]\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        output_items = input_items[0]\n        for i in range(2):\n        \tself.arr = np.real(input_items[0][0])\n\n        if self.lim > 0:\n        \tprint(\"sub: \", self.arr)\n        \tself.lim = self.lim - 1\n        \t\n        \t\n        return len(output_items)\n        \n        \n        \n        \n"
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[],
                  out_sig=[(np.complex64, 2)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              self.lim = 5
              self.arr = [1, 2]

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = self.arr
              if self.lim > 0:
                      print("pub: ", self.arr)
                      self.lim = self.lim-1
              return 2
    comment: esta parte envia arreglos de dim 2
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              self.lim = 5
              self.arr = 33

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = np.full(len(output_items[0]), self.arr)
              if self.lim > 0:
                      print("pub: ", self.arr)
                      print(output_items)
                      self.lim = self.lim-1
              return 2
    comment: esta parte envia arreglos de dim 2
    example_param: '1.0'
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              self.lim = 5
              self.arr = 33

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = np.full(len(output_items[0]), self.arr)
              if self.lim > 0:
                      print("pub: ", self.arr)
                      print(output_items)
                      self.lim = self.lim-1
              return 2
    comment: esta parte envia arreglos de dim 2
    example_param: '1.0'
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[],
                  out_sig=[(np.complex64, 2)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              self.lim = 5
              self.arr = [1, 2]

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = self.arr
              if self.lim > 0:
                      print("pub: ", self.arr)
                      self.lim = self.lim-1
              return 2
    comment: esta parte envia arreglos de dim 2
    example_param: '1.0'
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5610
    timeout: '100'
    type: complex
    vlen: '2'
  states: {state: disabled}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5610
    timeout: '1'
    type: float
  states: {}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5611
    timeout: '1'
    type: float
  states: {}
- name: zeromq_pub_sink_0_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5611
    timeout: '100'
    type: complex
    vlen: '2'
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5605
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_vector_to_stream_0, '0', zeromq_pub_sink_0, '0']
- [blocks_vector_to_stream_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', zeromq_pub_sink_0_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', zeromq_pub_sink_0_1, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_0_0, '0', blocks_vector_to_stream_0, '0']
- [epy_block_0_0_0, '0', zeromq_pub_sink_0_0, '0']
- [epy_block_0_0_0_0, '0', zeromq_pub_sink_0_0_0, '0']
- [epy_block_0_0_1, '0', blocks_vector_to_stream_0_1, '0']
- [zeromq_sub_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
