options:
  parameters:
    generate_options: qt_gui
    id: pasandoarreglos2
    output_language: python
    title: pasandoarreglos
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n\tdef __init__(self, example_param=1.0):  # only default arguments here\n\t\tgr.sync_block.__init__(\n\t\tself,\n\t\tname='Embedded Python Block',   # will show up in G\n\t\tin_sig=[np.complex64],\n\t\tout_sig=[(np.complex64, 1), (np.float32, 10)]\n\t\t)\n\t\tself.example_param = example_param\n\t\tself.arreglo = [1, 2, 3, 4, 5, 6, 7, 8, 9, 10]\n\t\tself.limite = 10\n\t\t\n\tdef work(self, input_items, output_items):\n\t\toutput_items[0][:] = input_items[0] * 2\n\t\toutput_items[1] = self.arreglo + np.ones(10)\n\t\tif self.limite > 0:\n\t\t\tprint(\"rx mando arreglo \", output_items[1])\n\t\t\tself.limite = self.limite - 1\n\t\t\t\n\t\treturn len(output_items[0])\n\n"
    example_param: '1.0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:6000
    timeout: '100'
    type: float
    vlen: '10'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:6001
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_null_source_0, '0', epy_block_0_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0_0, '1', zeromq_pub_sink_0_0, '0']
- [zeromq_sub_source_0, '0', epy_block_0_0, '0']

metadata:
  file_format: 1
